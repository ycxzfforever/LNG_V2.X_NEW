# IAR project LNG_V2.X_NEW.ewp, settings and files
configuration Debug (AVR, debug)
  General.LCHeapSize: 0x10
  General.SCCStackSize: 0x200
  General.SCRStackSize: 0x16
  General.LCTinyHeapSize: 0x10
  General.LCNearHeapSize: 0x20
  General.LCFarHeapSize: 0x1000
  General.LCHugeHeapSize: 0x1000
  ICCAVR.newCCIncludePaths: ../include
  ICCAVR.CCStdIncludePaths: $TOOLKIT_DIR$\INC\; $TOOLKIT_DIR$\INC\CLIB\
  XLINK.XclFile: $TOOLKIT_DIR$\src\template\cfgm1280.xcl
  XLINK.XExtraOptions: -y(CODE); -Ointel-extended,(DATA)=$EXE_DIR$\$PROJ_FNAME$_data.hex; -Ointel-extended,(XDATA)=$EXE_DIR$\$PROJ_FNAME$_eeprom.h
configuration Release (AVR)
  as the first configuration, except:
  General.SCCStackSize: 0x350
  General.SCRStackSize: 0x50
  ICCAVR.CCDefines: NDEBUG
  ICCAVR.IExtraOptions: --string_literals_in_flash
  XLINK.XExtraOptions: -y(CODE); -Ointel-extended,(DATA)=$EXE_DIR$\$PROJ_FNAME$_data.hex; -Ointel-extended,(XDATA)=$EXE_DIR$\$PROJ_FNAME$_eeprom.hex
  group (top)
    src/: app.c main.c
    ./: backup.txt read me.txt
  group app
    src/: controlparas.c devicetest.c ds3232.c menuset.c password.c printer.c query.c secdisplay.c store.c uart.c
  group lng
    src/: lngctrl.c
    include/: lngctrl.h
  group src
    src/: adc.c cpupinpredefine.c datatypetransform.c e28f128flash.c eeprom.c fyd12864.c i2c.c keyboard.c modbus.c mt318.c timer1.c timer3.c
