<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\LNG_V2.X_NEW.ewp</path>
  </project>
  <batchBuild/>
</workspace>


